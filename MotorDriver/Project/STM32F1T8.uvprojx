# Keil uVision project STM32F1T8.uvprojx, settings and files
target Target 1 (ARM-ADS)
  device: STM32F103C8 STMicroelectronics
  pack: Keil.STM32F1xx_DFP.1.0.5
  cpu: IROM(0x08000000,0x10000) IRAM(0x20000000,0x5000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: STM32F1T8 +hex
  c flags: Optim=1 OneElfS=1 uC99=1 wLevel=2
  c define: STM32F10X_MD,USE_STDPERIPH_DRIVER
  c include: ..\User;..\Libraries;..\CM3;..\Hardware
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group User
    ../User/: main.c stm32f10x_it.c
  group Lib
    ../Libraries/: misc.c stm32f10x_adc.c stm32f10x_can.c stm32f10x_dma.c stm32f10x_gpio.c stm32f10x_rcc.c stm32f10x_tim.c stm32f10x_flash.c stm32f10x_usart.c stm32f10x_i2c.c
  group HardWare
    ../Hardware/: adc.c can.c control.c delay.c encoder.c led.c pwm.c PID.c usart.c oled_spi.c oled_iic.c
  group CM
    ../CM3/: core_cm3.c system_stm32f10x.c startup_stm32f10x_md.s
